# Repository tocisz/watering2-kicad

## KiCad design watering2.kicad_pcb

Schematic: watering2.sch, Home plant watering system

Parts:
C4: 100uF; CP_Radial_D6.3mm_P2.50mm
C5, C6: 100nF; C_Disc_D5.0mm_W2.5mm_P2.50mm
D1, D2: LED; LED_D1.8mm_W3.3mm_H2.4mm
D3, D4, D5, D6: 1N4001; D_DO-41_SOD81_P10.16mm_Horizontal
J1: Conn_02x01; conn_power_2x01
J2: Conn_01x03_Female; Socket_Strip_Straight_1x03_Pitch2.54mm
J3, J4: CONN_02X03; Pin_Header_Straight_2x03_Pitch2.54mm
J5: Conn_02x04_Odd_Even; Pin_Header_Straight_2x04_Pitch2.54mm
L1: 10uH; Choke_Horizontal_RM10mm
Q1, Q2, Q3, Q4: BC558B; TO-92_Inline_Narrow_Oval
R1, R2, R3, R4, R5, R6, R7: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R8, R9, R10, R11, R13, R14: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R12: 5,1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW2: SW_DPDT_x2; SW_small
U1: DHT22
U2: ATMEGA88PA-PU; DIP-28_W7.62mm_Socket
U3: Radio-TX
U4: Radio-RX
Y1: 16384; Crystal_DS15_d1.5mm_l5.0mm_Vertical

Connections:
+5V: C4.1, L1.1, Q1.3, Q2.3, Q3.3, Q4.3, R2.1, R12.1, R13.2, SW2.2, U1.1, U2.7 (VCC), U4.1
/D1: R8.2, U2.6 ((PCINT20/XCK/T0)PD4)
/D2: R9.2, U2.11 ((PCINT21/OC0B/T1)PD5)
/D3: R10.2, U2.12 ((PCINT22/OC0A/AIN0)PD6)
/D4: R11.2, U2.13 ((PCINT23/AIN1)PD7)
/DHT: R12.2, U1.2, U2.4 ((PCINT18/INT0)PD2)
/M1EN: R1.2, R5.2, U2.14 ((PCINT0/CLKO/ICP1)PB0)
/M1_1: J3.5, R1.1, U2.23 ((PCINT8/ADC0)PC0)
/M1_2: J3.3, R3.1, U2.24 ((PCINT9/ADC1)PC1)
/M1_3: J3.1, R4.1, U2.25 ((PCINT10/ADC2)PC2)
/M2EN: R3.2, R6.2, U2.15 ((PCINT1/OC1A)PB1)
/M2_1: J4.5, R5.1, U2.26 ((PCINT11/ADC3)PC3)
/M2_2: J4.3, R6.1, U2.27 ((PCINT12/SDA/ADC4)PC4)
/M2_3: J4.1, R7.1, U2.28 ((PCINT13/SCL/ADC5)PC5)
/M3EN: R4.2, R7.2, U2.16 ((PCINT2/OC1B/~SS~)PB2)
/RX: J2.2, U2.2 ((PCINT16/RXD)PD0)
/R_RX: U2.17 ((PCINT3/OC2A/MOSI)PB3), U4.2, U4.3
/R_TX: U2.19 ((PCINT5/SCK)PB5), U3.1
/R_TX_EN: U2.18 ((PCINT4/MISO)PB4), U3.2
/STATUS: R14.2, U2.5 ((PCINT19/OC2B/INT1)PD3)
/TX: J2.3, U2.3 ((PCINT17/TXD)PD1)
GND: C4.2, C5.2, C6.2, D1.1, D2.1, D3.2, D4.2, D5.2, D6.2, J2.1, J3.2, J3.4, J3.6, J4.2, J4.4, J4.6, J5.2, J5.4, J5.6, J5.8, SW2.5, U1.4, U2.8 (GND), U2.22 (GND), U3.3, U4.4
unnamed: C5.1, L1.2, U2.20 (AVCC)
unnamed: C6.1, U2.21 (AREF)
unnamed: D1.2, R13.1
unnamed: D2.2, R14.1
unnamed: D3.1, J5.7, Q1.1
unnamed: D4.1, J5.5, Q2.1
unnamed: D5.1, J5.3, Q3.1
unnamed: D6.1, J5.1, Q4.1
unnamed: J1.1, SW2.6
unnamed: J1.2, SW2.3
unnamed: Q1.2, R8.1
unnamed: Q2.2, R9.1
unnamed: Q3.2, R10.1
unnamed: Q4.2, R11.1
unnamed: R2.2, U2.1 ((PCINT14/~RESET~)PC6)
unnamed: U2.9 ((PCINT6/XTAL1/TOSC1)PB6), Y1.1
unnamed: U2.10 ((PCINT7/XTAL2/TOSC2)PB7), Y1.2

Notes on the sheet:
UART
Measure Connectors
Drive Connectors
Radio
Humidity and Temperature

Board: 2 copper layers, 61.0 x 73.7 mm, 39 parts (4 on the bottom side), 39 nets.

## Commit log

2018-07-11 Watering driver pcb
2018-07-11 Add net
2018-07-20 fix wrong transistor connection
2018-07-20 todo
2018-07-20 rotate power connector
2018-07-20 wider switch footprint
2018-07-20 make footprints look nice
2018-07-21 fix transmitter symbol
2018-07-21 Use PNP transistor
2018-07-21 big flyback diodes
2018-07-21 fiddle with diode position
